# Repository retrorgb/COMP2DVI

File README.md:

# COMP2DVI
Please refer to the [COMP2DVI](https://www.retrorgb.com/comp2dvi.html) page on RetroRGB for more information.

## KiCad design Component to DVI-A Compact.kicad_pcb

Board: 2 copper layers, 57.8 x 48.4 mm, 27 parts (0 on the bottom side), 20 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
C2, C3, C6: 220uF; SMC_C
C4, C9, C10, C11: 100nF; C0603
C5: 100uF 6.3V; PANASONIC_B
FB1: FB_330R; L2012C
J3: 629105150521
R1, R2, R3, R11, R15, R16, R17: 75R; R0603
U1: THS7374; SO14W
U$1, U$2, U$4: CIU_RCJ-01X
U$3: JS202011
X2: DVI-I-R

Connections:
+5V: FB1.2, J3.1
/DVI_OUT_B: C6.-, X2.C3
/DVI_OUT_G: C2.-, X2.C2
/DVI_OUT_R: C3.-, X2.C1
/SCART_IN_B: C11.2, R3.2, U$4.1
/SCART_IN_G: C10.2, R2.2, U$2.1
/SCART_IN_R: C9.2, R1.2, U$1.1
/THS_5V: C4.1, C5.+, FB1.1, U1.10, U$3.3, U$3.6
/THS_FILTER: U1.9, U$3.2, U$3.5
/THS_IN_B: C11.1, U1.4
/THS_IN_G: C10.1, U1.2
/THS_IN_R: C9.1, U1.3
GND: C4.2, C5.-, J3.5, J3.SHELL, J3.SHELL1, J3.SHELL2, J3.SHELL3, R1.1, R2.1, R3.1, R11.2, U1.5, U1.6, U$1.2@1, U$1.2@2, U$1.2@3, U$2.2@1, U$2.2@2, U$2.2@3, U$3.1, U$3.4, U$4.2@1, U$4.2@2, U$4.2@3, X2.3, X2.11, X2.15, X2.19, X2.C5, X2.GND@1, X2.GND@2
unnamed: C2.+, R16.1
unnamed: C3.+, R15.1
unnamed: C6.+, R17.1
unnamed: R11.1, U1.1
unnamed: R15.2, U1.12
unnamed: R16.2, U1.13
unnamed: R17.2, U1.11

## KiCad design comp2dvi2.kicad_pcb

Parts:
C1, C2, C3, C5: 100nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C4: 10μF; CP_Elec_4x5.4
C6: 10nF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C7, C8, C9: 470μF; CP_Elec_10x10
FB1: 220Ω; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J3: Conn_Coaxial; CIU_RCJ-01X
J4: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J5: DVI-I-R
R1, R2, R3, R7, R8, R9: 75Ω; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4, R5, R6: 5.36M; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R10, R11, R12: 100K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1: SW_DIP_x02; SW_DIP_SPSTx02_Piano_10.8x6.64mm_W7.62mm_P2.54mm
SW2: SW_DPDT_x2; JS202011
U1: THS7368; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
5V: C4.1, C5.2, C6.2, FB1.1, R4.1, R5.1, R6.1, SW1.3, SW1.4, SW2.3, SW2.6, U1.5, U1.17
BYPASS: R12.2, SW2.2, SW2.5, U1.11
FILTER1: R10.2, SW1.1, U1.6
FILTER2: R11.2, SW1.2, U1.4
GND: C4.2, C5.1, C6.1, J1.2 (Ext), J2.2 (Ext), J3.2 (Ext), J4.5 (GND), J4.6 (Shield), J5.3, J5.11, J5.15, J5.19, J5.22, J5.C5, J5.GND@1, J5.GND@2, R1.1, R2.1, R3.1, R10.1, R11.1, R12.1, U1.1, U1.2, U1.3, U1.15, U1.16
unnamed: C7.1, R7.1
unnamed: C8.1, R8.1
unnamed: C9.1, R9.1
unnamed: FB1.2, J4.1 (VBUS)
unnamed: R7.2, U1.14
unnamed: R8.2, U1.13
unnamed: R9.2, U1.12
unnamed: SW2.1, SW2.4
Pb: C3.2, J2.1 (In), R3.2
Pb_OUT: C9.2, J5.C3
Pr: C1.2, J3.1 (In), R1.2
Pr_OUT: C7.2, J5.C1
SF1_IN: C1.1, R4.2, U1.7
SF2_IN: C2.1, R5.2, U1.8
SF3_IN: C3.1, R6.2, U1.9
Y: C2.2, J1.1 (In), R2.2
Y_OUT: C8.2, J5.C2

Notes on the sheet:
Truth Table: 0 is up, 1 is down Filter 1 Filter 2 Bypass 0 0 0 | SD 240p 9.5MHz 0 1 0 | ED 480p 17MHz 1 0 0 | HD 720p 35MHz 1 1 0 | FHD 1080p 70MHz X X 1 | Filter Off

Board: 2 copper layers, 44.1 x 62.0 mm, 30 parts (0 on the bottom side), 22 nets.

File COMP2DVI_BOM.xlsx:

Qty | Reference(s) | Value | Footprint | Description | Digikey | Arrow | LCSC | Alternate Parts
4 | C1, C2, C3, C5 | 100nF/0.1uF | 0603 | Ceramic 50V X7R | https://www.digikey.com/product-detail/en/CL10F104ZO8NNNC/12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 | https://www.arrow.com/en/products/cl10f104zo8nnnc/samsung-el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 | https://lcsc.com/product-detail/Multilayer-Ceramic-Capacitor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
1 | C4 | 10 uF | 4x5.4 | Elec. 25-50V | https://www.digikey.com/product-detail/en/panasonic-electron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 | https://www.arrow.com/en/products/eeefk1e100r/panasonic | https://lcsc.com/product-detail/Others_PANASONIC-EEE1EA100WA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
1 | C6 | 10nF | 0603 | Ceramic 50V X7R | https://www.digikey.com/product-detail/en/samsung-electro-me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 | https://www.arrow.com/en/products/cc0603krx7r9bb103/yageo | https://lcsc.com/product-detail/Others_Samsung-Electro-Mecha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
3 | C7, C8, C9 | 470uF | 10x10 | Elec. 25V | https://www.digikey.com/product-detail/en/nichicon/UCW1E471M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 | https://www.arrow.com/en/products/uwg1e471mnl1gs/nichicon | https://lcsc.com/product-detail/Others_Nichicon-UCW1E471MNL1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
1 | FB1 | 220Ω | 0603 | Ferrite Bead | https://www.digikey.com/product-detail/en/tdk-corporation/MP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 | https://www.arrow.com/en/products/mpz1608s221ata00/tdk | https://lcsc.com/product-detail/Ferrite-Beads-And-Chips_TDK_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
6 | R1, R2, R3, R7, R8, R9 | 75Ω | 0603 | 0.01 | https://www.digikey.com/product-detail/en/rohm-semiconductor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 | https://www.arrow.com/en/products/erj-3ekf75r0v/panasonic | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
3 | R4, R5, R6 | 5.36M | 0603 | 0.01 | https://www.digikey.com/product-detail/en/vishay-dale/CRCW06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 | https://www.arrow.com/en/products/crcw06035m36fkea/vishay |  | not available from lcsc
3 | R10, R11, R12 | 100K | 0603 | 0.01 | https://www.digikey.com/product-detail/en/yageo/RC0603FR-071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 | https://www.arrow.com/en/products/erj-3ekf1003v/panasonic | https://lcsc.com/product-detail/Chip-Resistor-Surface-Mount_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
1 | U1 | THS7368 | TSSOP-20 |  | https://www.digikey.com/product-detail/en/texas-instruments/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 | https://www.arrow.com/en/products/ths7368ipw/texas-instruments | https://lcsc.com/product-detail/Operational-Amplifiers_TI_TH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
1 | SW1 | DIP Switch | 1x3 DIP | Piano | https://www.digikey.com/product-detail/en/omron-electronics-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 | https://www.arrow.com/en/products/a6fr3104/omron | https://lcsc.com/product-detail/DIP-Switches_Made-in-China-V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 | https://lcsc.com/product-detail/DIP-Switches_Korean-Hroparts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 | digikey/arrow: black, lcsc: red or blue
1 | J1 | RCA Jack | 4 or 2 pin | Y (Green) | https://www.digikey.com/product-detail/en/RCJ-016/CP-1405-ND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 | https://www.arrow.com/en/products/rcj-016/cui-inc | https://lcsc.com/product-detail/AV-Connectors_AV-5_C18080.html | RCJ-046 | LCSC part is yellow
2 | J2 | RCA Jack | 4 or 2 pin | Pb (Blue) | https://www.digikey.com/product-detail/en/RCJ-015/CP-1404-ND/408491 | https://www.arrow.com/en/products/rcj-015/cui-inc |  | RCJ-045
3 | J3 | RCA Jack | 4 or 2 pin | Pr (Red) | https://www.digikey.com/product-detail/en/cui-inc/RCJ-012/CP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 | https://www.arrow.com/en/products/rcj-012/cui-inc |  | RCJ-042
1 | J4 | Micro USB | Micro USB |  | https://www.digikey.com/product-detail/en/wurth-electronics-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 | https://www.arrow.com/en/products/uj2-mibh-4-smt-tr/cui-inc | https://lcsc.com/product-detail/USB-Connectors_Jing-Extensio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 |  | arrow part works but sticks out and tabs need to be bent slightly, lcsc part al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
1 | J5 | DVI-I | DVI-I |  | https://www.digikey.com/product-detail/en/molex-llc/07432010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 | https://www.arrow.com/en/products/0743201004/molex | https://lcsc.com/product-detail/Audio-Video-Connectors_CONNF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
2 | DVI SCREWS |  | #4 |  | https://www.digikey.com/product-detail/en/te-connectivity-am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 | https://www.arrow.com/en/products/5207953-3/te-connectivity

## Commit log

2019-06-13 Initial Eagle Version
    Initial Eagle version of the Comp2DVI
2019-06-13 Converted to KiCAD
2019-06-13 2.1 version
    Changed to THS7368 amp. This involced adding a dip switch and selector switch to determine the bandwidth of the video filter. Changed micro-usb port to a more commonly available part.
2019-06-13 Create license
2019-06-13 Added README
2019-06-17 Bypass Cap Routing
    Fixed routing so that the power from the USB goes to the 100nF bypass cap before hitting the chip. Thanks to Tianfeng for pointing this out. Gerbers updated as well.
2019-06-17 renamed gerber zip
2019-06-26 Fixed overlapping silkscreen
    Fixed overlap, won't change version number or make a new release for this.
2019-08-18 Updated BOM
    BOM now matches current version and includes case hardware.
2019-10-24 removed old files

Notices in the files:
comp2dvi2.kicad_pcb:
Licensed Under CERN OHL 1.2
